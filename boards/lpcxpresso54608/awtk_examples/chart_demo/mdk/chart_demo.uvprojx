# Keil uVision project chart_demo.uvprojx, settings and files
target chart_demo debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC54608J512ET180 NXP
  pack: NXP.LPC54608_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: chart_demo.out
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 wLevel=2
  c define: DEBUG, CPU_LPC54608, CPU_LPC54608J512ET180=1,HAS_AWTK_CONFIG
  c misc: --library_interface=armcc --diag_suppress=1296,186 --gnu
  c include: ..;../../..;../../../../../CMSIS/Include;../../../../../devices;../../../../../devices/LPC54608;../../../../../middleware/emwin/emWin_Config;../../../../../middleware/emwin/emWin_header;../../../../../devices/LPC54608/drivers;../../../../../devices/LPC54608/drivers;../../../../../devices/LPC54608/drivers;../../../../../devices/LPC54608/drivers;../../../../../devices/LPC54608/drivers;../../../../../components/ft5406;../../../../../devices/LPC54608/drivers;../../../../../devices/LPC54608/drivers;../../../../../devices/LPC54608/drivers;../../../../../devices/LPC54608/drivers;../../../../../devices/LPC54608;../../../../../devices/LPC54608/utilities/str;../../../../../devices/LPC54608/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/serial_manager;../../../../../devices/LPC54608/drivers;../../../../../components/lists;../../../../../devices/LPC54608/drivers;../../../../../devices/LPC54608/drivers;../../../../../devices/LPC54608/drivers;..\..\..\..\..\middleware\awtk\src;..\..\..\..\..\middleware\awtk\src\ext_widgets;..\..\..\..\..\middleware\awtk\3rd;..\..\..\..\..\middleware\awtk\3rd\agge;..\..\..\..\..\middleware\awtk\3rd\agge\agge;..\..\..\..\..\middleware\awtk\3rd\nanovg;..\..\..\..\..\middleware\awtk\3rd\nanovg\base;..\..\..\..\..\middleware\awtk\3rd\gpinyin\include;..\..\..\..\..\middleware\awtk\3rd\libunibreak;..\Chart-Demo\src;..\Chart-Demo\src\custom_widgets;..\Chart-Demo\src\custom_widgets\chart;..\Chart-Demo\src\custom_widgets\pie_slice;..\awtk-port
  asm define: DEBUG,__CC_ARM,KEIL, DEBUG
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
  scatter file: LPC54608J512_flash.scf
  link misc: ../../../../../devices/LPC54608/arm/keil_lib_power.lib  --remove
  group source
    ../: chart_demo.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/LPC54608/drivers/: fsl_iocon.h fsl_gpio.c fsl_gpio.h fsl_sctimer.c fsl_sctimer.h fsl_lcdc.c fsl_lcdc.h fsl_i2c.c fsl_i2c.h fsl_ctimer.c fsl_ctimer.h fsl_common.c fsl_common.h fsl_clock.c fsl_clock.h fsl_power.c fsl_power.h fsl_usart.c fsl_usart.h fsl_flexcomm.c fsl_flexcomm.h fsl_emc.c fsl_emc.h fsl_reset.c fsl_reset.h fsl_spifi.c fsl_spifi.h
  group touchpanel
    ../../../../../components/ft5406/: fsl_ft5406.c fsl_ft5406.h
  group emwin-emWin_Config
    ../../../../../middleware/emwin/emWin_Config/: GUIConf.h LCDConf.h
  group emwin-emWin_header
    ../../../../../middleware/emwin/emWin_header/: BUTTON.h BUTTON_Private.h CALENDAR.h CHECKBOX.h CHECKBOX_Private.h CHOOSECOLOR.h CHOOSEFILE.h DIALOG.h DIALOG_Intern.h DROPDOWN.h DROPDOWN_Private.h EDIT.h EDIT_Private.h FRAMEWIN.h FRAMEWIN_Private.h GRAPH.h GRAPH_Private.h GUI.h GUIDRV_BitPlains.h GUIDRV_DCache.h GUIDRV_DCache_Private.h GUIDRV_Dist.h GUIDRV_FlexColor.h GUIDRV_FlexColor_Private.h GUIDRV_IST3088.h GUIDRV_IST3088_Private.h GUIDRV_Lin.h GUIDRV_Lin_Opt_16.h GUIDRV_Lin_Opt_24.h GUIDRV_Lin_Opt_32.h GUIDRV_Lin_Opt_8.h GUIDRV_Lin_Private.h GUIDRV_NoOpt_1_8.h GUIDRV_S1D13748.h GUIDRV_S1D13748_Private.h GUIDRV_S1D13781.h GUIDRV_S1D13781_Private.h GUIDRV_S1D15G00.h GUIDRV_SLin.h GUIDRV_SLin_Private.h GUIDRV_SPage.h GUIDRV_SPage_Private.h GUIDRV_SSD1926.h GUIDRV_SSD1926_Private.h GUIDRV_Template.h GUIDRV_TemplateI.h GUIDRV_TemplateI_Private.h GUITDRV_ADS7846.h GUI_ARRAY.h GUI_ARRAY_Private.h GUI_BMP_Private.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_GCache_Private.h GUI_GIF_Private.h GUI_HOOK.h GUI_JPEG_Private.h GUI_Private.h GUI_SPRITE_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_Type.h GUI_VNC.h GUI_Version.h GUI__BiDi2_Brackets_800.h GUI__BiDi2_Types_800.h Global.h HEADER.h HEADER_Private.h ICONVIEW.h ICONVIEW_Private.h IMAGE.h IMAGE_Private.h IP_FS.h KNOB.h KNOB_Private.h LCD.h LCD_ConfDefaults.h LCD_Private.h LCD_Protected.h LCD_SIM.h LISTBOX.h LISTBOX_Private.h LISTVIEW.h LISTVIEW_Private.h LISTWHEEL.h LISTWHEEL_Private.h MENU.h MENU_Private.h MESSAGEBOX.h MULTIEDIT.h MULTIPAGE.h MULTIPAGE_Private.h PROGBAR.h PROGBAR_Private.h RADIO.h RADIO_Private.h SCROLLBAR.h SCROLLBAR_Private.h SEGGER.h SLIDER.h SLIDER_Private.h SPINBOX.h SPINBOX_Private.h SWIPELIST.h SWIPELIST_Private.h TEXT.h TEXT_Private.h TREEVIEW.h TREEVIEW_Private.h WIDGET.h WINDOW_Private.h WM.h WM_GUI.h WM_Intern.h
  group device
    ../../../../../devices/LPC54608/: LPC54608.h LPC54608_features.h fsl_device_registers.h system_LPC54608.c system_LPC54608.h
  group utilities
    ../../../../../devices/LPC54608/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/LPC54608/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/LPC54608/utilities/: fsl_assert.c
  group component-uart
    ../../../../../components/uart/: uart.h usart_adapter.c
  group component-serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/LPC54608/arm/: startup_LPC54608.s
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h
  group awtk-src
    ../../../../../middleware/awtk/src/: awtk.h awtk_base.h awtk_ext_widgets.h awtk_global.c awtk_global.h awtk_tkc.h awtk_widgets.h
  group awtk-src-base
    ../../../../../middleware/awtk/src/base/: assets_manager.c assets_manager.h awtk_config_sample.h bitmap.c bitmap.h canvas.c canvas.h children_layouter.c children_layouter.h children_layouter_factory.c children_layouter_factory.h clip_board.c clip_board.h dialog_highlighter.c dialog_highlighter.h dialog_highlighter_factory.c dialog_highlighter_factory.h enums.c enums.h event_queue.c event_queue.h events.c events.h font.c font.h font_loader.c font_loader.h font_manager.c font_manager.h g2d.h glyph_cache.c glyph_cache.h hscrollable.c hscrollable.h idle.c idle.h idle_info.c idle_info.h idle_manager.c idle_manager.h image_base.c image_base.h image_loader.c image_loader.h image_manager.c image_manager.h input_device_status.c input_device_status.h input_engine.c input_engine.h input_method.c input_method.h keys.h layout.c layout.h layout_def.h lcd.c lcd.h lcd_profile.c lcd_profile.h line_break.c line_break.h locale_info.c locale_info.h main_loop.c main_loop.h pixel.h pixel_pack_unpack.h rom_fs.c rom_fs.h self_layouter.c self_layouter.h self_layouter_factory.c self_layouter_factory.h shortcut.c shortcut.h style.c style.h style_const.c style_const.h style_factory.c style_factory.h style_mutable.c style_mutable.h suggest_words.c suggest_words.h system_info.c system_info.h text_edit.c text_edit.h theme.c theme.h timer.c timer.h timer_info.c timer_info.h timer_manager.c timer_manager.h types_def.h ui_builder.c ui_builder.h ui_loader.c ui_loader.h velocity.c velocity.h vgcanvas.c vgcanvas.h widget.c widget.h widget_animator.c widget_animator.h widget_animator_factory.h widget_animator_factory_null.c widget_animator_manager.c widget_animator_manager.h widget_consts.h widget_factory.c widget_factory.h widget_pool.c widget_pool.h widget_vtable.c widget_vtable.h window_animator.c window_animator.h window_animator_factory.c window_animator_factory.h window_base.c window_base.h window_manager.c window_manager.h wuxiaolin.inc
  group awtk-src-blend
    ../../../../../middleware/awtk/src/blend/: blend_image.inc blend_image_bgr565_bgr565.c blend_image_bgr565_bgr565.h blend_image_bgr565_bgra8888.c blend_image_bgr565_bgra8888.h blend_image_bgr565_rgba8888.c blend_image_bgr565_rgba8888.h blend_image_bgr888_bgr565.c blend_image_bgr888_bgr565.h blend_image_bgr888_bgra8888.c blend_image_bgr888_bgra8888.h blend_image_bgr888_rgba8888.c blend_image_bgr888_rgba8888.h blend_image_bgra8888_bgr565.c blend_image_bgra8888_bgr565.h blend_image_bgra8888_bgra8888.c blend_image_bgra8888_bgra8888.h blend_image_bgra8888_rgba8888.c blend_image_bgra8888_rgba8888.h blend_image_rgb565_bgr565.c blend_image_rgb565_bgr565.h blend_image_rgb565_bgra8888.c blend_image_rgb565_bgra8888.h blend_image_rgb565_rgba8888.c blend_image_rgb565_rgba8888.h blend_image_rgba8888_bgr565.c blend_image_rgba8888_bgr565.h blend_image_rgba8888_bgra8888.c blend_image_rgba8888_bgra8888.h blend_image_rgba8888_rgba8888.c blend_image_rgba8888_rgba8888.h fill_image.inc fill_image_abgr8888.c fill_image_abgr8888.h fill_image_argb8888.c fill_image_argb8888.h fill_image_bgr565.c fill_image_bgr565.h fill_image_bgr888.c fill_image_bgr888.h fill_image_bgra8888.c fill_image_bgra8888.h fill_image_rgb565.c fill_image_rgb565.h fill_image_rgba8888.c fill_image_rgba8888.h image_g2d.c image_g2d.h pixel_ops.inc rotate_image.inc rotate_image_bgr565.c rotate_image_bgr565.h rotate_image_bgr888.c rotate_image_bgr888.h rotate_image_bgra8888.c rotate_image_bgra8888.h rotate_image_rgb565.c rotate_image_rgb565.h rotate_image_rgba8888.c rotate_image_rgba8888.h soft_g2d.c soft_g2d.h stm32_g2d.c
  group awtk-src-clip_aboard
    ../../../../../middleware/awtk/src/clip_board/: clip_board_default.c clip_board_default.h clip_board_sdl.c clip_board_sdl.h
  group awtk-src-dialog_highlighters
    ../../../../../middleware/awtk/src/dialog_highlighters/: dialog_highlighter_default.h dialog_highlighter_builtins.c dialog_highlighter_builtins.h dialog_highlighter_default.c
  group awtk-src-ext_widgets
    ../../../../../middleware/awtk/src/ext_widgets/: ext_widgets.c ext_widgets.h
    ../../../../../middleware/awtk/src/ext_widgets/canvas_widget/: canvas_widget.c canvas_widget.h
    ../../../../../middleware/awtk/src/ext_widgets/color_picker/: color_component.c color_component.h color_picker.c color_picker.h color_picker_const.h rgb_and_hsv.c rgb_and_hsv.h
    ../../../../../middleware/awtk/src/ext_widgets/gif_image/: gif_image.c gif_image.h
    ../../../../../middleware/awtk/src/ext_widgets/guage/: guage.c guage.h guage_pointer.c guage_pointer.h
    ../../../../../middleware/awtk/src/ext_widgets/image_animation/: image_animation.c image_animation.h
    ../../../../../middleware/awtk/src/ext_widgets/image_value/: image_value.c image_value.h
    ../../../../../middleware/awtk/src/ext_widgets/keyboard/: candidates.c candidates.h keyboard.c keyboard.h
    ../../../../../middleware/awtk/src/ext_widgets/mledit/: line_number.c line_number.h mledit.c mledit.h
    ../../../../../middleware/awtk/src/ext_widgets/mutable_image/: mutable_image.c mutable_image.h
    ../../../../../middleware/awtk/src/ext_widgets/progress_circle/: progress_circle.c progress_circle.h
    ../../../../../middleware/awtk/src/ext_widgets/rich_text/: rich_text.c rich_text.h rich_text_node.c rich_text_node.h rich_text_parser.c rich_text_parser.h rich_text_render_node.c rich_text_render_node.h
    ../../../../../middleware/awtk/src/ext_widgets/scroll_label/: hscroll_label.c hscroll_label.h
    ../../../../../middleware/awtk/src/ext_widgets/scroll_view/: children_layouter_list_view.c children_layouter_list_view.h list_item.c list_item.h list_view.c list_view.h list_view_h.c list_view_h.h scroll_bar.c scroll_bar.h scroll_view.c scroll_view.h
    ../../../../../middleware/awtk/src/ext_widgets/slide_menu/: slide_menu.c slide_menu.h
    ../../../../../middleware/awtk/src/ext_widgets/slide_view/: slide_indicator.c slide_indicator.h slide_view.c slide_view.h
    ../../../../../middleware/awtk/src/ext_widgets/svg_image/: svg_image.c svg_image.h
    ../../../../../middleware/awtk/src/ext_widgets/switch/: switch.c switch.h
    ../../../../../middleware/awtk/src/ext_widgets/text_selector/: text_selector.c text_selector.h
    ../../../../../middleware/awtk/src/ext_widgets/time_clock/: digit_clock.c digit_clock.h time_clock.c time_clock.h
  group awtk-src-font_loader
    ../../../../../middleware/awtk/src/font_loader/: font_loader_bitmap.c font_loader_bitmap.h font_loader_ft.c font_loader_ft.h font_loader_stb.c font_loader_stb.h font_loader_truetype.h
  group awtk-src-image_loader
    ../../../../../middleware/awtk/src/image_loader/: image_loader_stb.c image_loader_stb.h
  group awtk-src-input_engines
    ../../../../../middleware/awtk/src/input_engines/: input_engine_null.c input_engine_null.h input_engine_pinyin.cpp input_engine_pinyin.h
  group awtk-src-input_methods
    ../../../../../middleware/awtk/src/input_methods/: input_method_creator.c input_method_default.h input_method_default.inc input_method_null.h input_method_null.inc input_method_sdl.h input_method_sdl.inc suggest_words.inc
  group awtk-src-layouters
    ../../../../../middleware/awtk/src/layouters/: children_layouter_builtins.c children_layouter_builtins.h children_layouter_default.c children_layouter_default.h children_layouter_parser.c self_layouter_builtins.c self_layouter_builtins.h self_layouter_default.c self_layouter_default.h self_layouter_menu.c self_layouter_menu.h self_layouter_parser.c
  group awtk-src-lcd
    ../../../../../middleware/awtk/src/lcd/: lcd_mem_rgb565.h lcd_mem_rgb565.c lcd_mem.h lcd_mem.inc lcd_mem_bgr565.c lcd_mem_bgr565.h lcd_mem_bgr888.c lcd_mem_bgr888.h lcd_mem_bgra8888.c lcd_mem_bgra8888.h lcd_mem_rgba8888.c lcd_mem_rgba8888.h
  group awtk-src-main_loop
    ../../../../../middleware/awtk/src/main_loop/: main_loop_simple.c main_loop_simple.h
  group awtk-src-misc
    ../../../../../middleware/awtk/src/misc/: new.cpp new.hpp test_cpp.cpp
  group awtk-src-platforms
    ../../../../../middleware/awtk/src/platforms/raw/: fs_os.c mutex_null.c sys_tick.c cond_var_null.c
  group awtk-src-svg
    ../../../../../middleware/awtk/src/svg/: bsvg.c bsvg.h bsvg_builder.c bsvg_builder.h bsvg_common.h bsvg_draw.c bsvg_draw.h bsvg_to_svg.c bsvg_to_svg.h svg_path.c svg_path.h svg_path_parser.c svg_path_parser.h svg_shape.c svg_shape.h svg_to_bsvg.c svg_to_bsvg.h
  group awtk-src-tkc
    ../../../../../middleware/awtk/src/tkc/: buffer.c buffer.h color.c color.h color_parser.c color_parser.h cond_var.h darray.c darray.h date_time.c date_time.h easing.c easing.h emitter.c emitter.h event.c event.h expr_eval.c expr_eval.h fs.c fs.h func_call_parser.c func_call_parser.h int_str.c int_str.h matrix.c matrix.h mem.c mem.h mutex.h named_value.c named_value.h object.c object.h object_default.c object_default.h path.c path.h platform.h rect.c rect.h slist.c slist.h str.c str.h str_str.c str_str.h thread.h time_now.c time_now.h tokenizer.c tokenizer.h types_def.h utf8.c utf8.h utils.c utils.h value.c value.h wstr.c wstr.h
  group awtk-src-ui_loader
    ../../../../../middleware/awtk/src/ui_loader/: ui_binary_writer.c ui_binary_writer.h ui_builder_default.c ui_builder_default.h ui_loader_default.c ui_loader_default.h ui_loader_xml.c ui_loader_xml.h ui_serializer.c ui_serializer.h ui_xml_writer.c ui_xml_writer.h window_open.c
  group awtk-src-vgcanvas
    ../../../../../middleware/awtk/src/vgcanvas/: vgcanvas_nanovg_soft.c vgcanvas_null.c
  group awtk-src-widget_animators
    ../../../../../middleware/awtk/src/widget_animators/: widget_animator_factory.c widget_animator_move.h widget_animator_opacity.h widget_animator_prop.c widget_animator_prop.h widget_animator_prop2.c widget_animator_prop2.h widget_animator_rotation.h widget_animator_scale.h widget_animator_scroll.c widget_animator_scroll.h widget_animator_value.h
  group awtk-src-widgets
    ../../../../../middleware/awtk/src/widgets/: app_bar.c app_bar.h button.c button.h button_group.c button_group.h calibration_win.c calibration_win.h check_button.c check_button.h color_tile.c color_tile.h column.c column.h combo_box.c combo_box.h combo_box_item.c combo_box_item.h dialog.c dialog.h dialog_client.c dialog_client.h dialog_title.c dialog_title.h dragger.c dragger.h edit.c edit.h grid.c grid.h grid_item.c grid_item.h group_box.c group_box.h image.c image.h label.c label.h overlay.c overlay.h pages.c pages.h popup.c popup.h progress_bar.c progress_bar.h row.c row.h slider.c slider.h spin_box.c spin_box.h system_bar.c system_bar.h tab_button.c tab_button.h tab_button_group.c tab_button_group.h tab_control.c tab_control.h view.c view.h window.c window.h
  group awtk-src-window_animators
    ../../../../../middleware/awtk/src/window_animators/: window_animator_builtins.c window_animator_builtins.h window_animator_center_scale.c window_animator_center_scale.h window_animator_common.c window_animator_common.h window_animator_fade.c window_animator_fade.h window_animator_htranslate.c window_animator_htranslate.h window_animator_popdown.c window_animator_popdown.h window_animator_popup.c window_animator_popup.h window_animator_slide.c window_animator_slide.h window_animator_slide_down.c window_animator_slide_down.h window_animator_slide_left.c window_animator_slide_left.h window_animator_slide_right.c window_animator_slide_right.h window_animator_slide_up.c window_animator_slide_up.h window_animator_vtranslate.c window_animator_vtranslate.h
  group awtk-src-xml
    ../../../../../middleware/awtk/src/xml/: xml_builder.c xml_builder.h xml_parser.c xml_parser.h
  group awtk-3rd-agge
    ../../../../../middleware/awtk/3rd/agge/agge/: bitmap.h blender_linear_gradient.h blender_radial_gradient.h blenders_generic.h clipper.h config.h filling_rules.h math.cpp math.h memory.h path.h pixel.h pixel_a.h pixel_convert.h pixel_set_a.h pod_vector.h precise_delta.h rasterizer.h renderer.h scanline.h stroke.cpp stroke.h stroke_features.cpp stroke_features.h tools.h types.h vector_rasterizer.cpp vector_rasterizer.h vertex_sequence.h
  group awtk-3rd-gpinyin
    ../../../../../middleware/awtk/3rd/gpinyin/src/: dictlist.cpp dicttrie.cpp gpinyin.inc lpicache.cpp matrixsearch.cpp mystdlib.cpp ngram.cpp pinyinime.cpp searchutility.cpp spellingtrie.cpp splparser.cpp utf16char.cpp
  group awtk-3rd-nanovg-base
    ../../../../../middleware/awtk/3rd/nanovg/base/: fontstash.h nanovg.c nanovg.h stb_image.h stb_truetype.h
  group awtk-3rd-nanovg-agge
    ../../../../../middleware/awtk/3rd/nanovg/agge/: nanovg_agge.cpp nanovg_agge.h nanovg_image_blender.h nanovg_vertex.cpp nanovg_vertex.h raw_bitmap.h
  group awtk-3rd-libunibreak
    ../../../../../middleware/awtk/3rd/libunibreak/: emojidata.inc emojidef.c emojidef.h graphemebreak.c graphemebreak.h graphemebreakdata.inc graphemebreakdef.h linebreak.c linebreak.h linebreakdata.c linebreakdef.c linebreakdef.h unibreakbase.c unibreakbase.h unibreakdef.c unibreakdef.h wordbreak.c wordbreak.h wordbreakdata.inc wordbreakdef.h
  group awtk-port
    ../awtk-port/: awtk_config.h main_loop_lpcxpresso54608_raw.c platform.c spifi_polling_transfer.c
  group awtk-demo
    ../Chart-Demo/src/: app_main.c window_bar_series.c window_line_series.c window_main.c window_meter.c window_pie.c
    ../Chart-Demo/src/custom_widgets/: custom_widgets.c custom_widgets.h
    ../Chart-Demo/src/custom_widgets/chart/: axis.c axis.h axis_render.c axis_render.h bar_series.c bar_series.h chart_animator.c chart_animator.h chart_utils.c chart_utils.h chart_view.c chart_view.h line_series.c line_series.h series.c series.h
    ../Chart-Demo/src/custom_widgets/pie_slice/: pie_slice.c pie_slice.h
